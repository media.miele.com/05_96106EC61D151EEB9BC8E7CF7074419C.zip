Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-02-09T07:11:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 09 07:11:17 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{66C589A4-9D29-4FE9-8299-C11BCB91D330}\ifc * Database version: 5507 * Database creation date: Tue Feb 09 07:11:16 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 09 07:11:16 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 09 07:11:16 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26746400_BR_11276370_KM7464FR, 11276370_BR_KM7464FR:26746400_BR_11276370_KM7464FR:204696
In: Level 1
Type - Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_Stainless Steel, z_Miele_Connection_Electric, Default
Pset_BuildingElementProxyCommon - Reference: 26746400_BR_11276370_KM7464FR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
